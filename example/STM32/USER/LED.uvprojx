# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\USART;..\SYSTEM\TIM;..\SYSTEM\ADC;..\SYSTEM\gpio;..\USER;..\CORE;..\HARDWARE\U8g2_V2.0.0;..\HARDWARE\U8g2_user;..\HARDWARE\matrixKey_V1.0.0;..\HARDWARE\button;..\HARDWARE\DeviceLink;..\..\..\library\core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/matrixKey_V1.0.0/: matrixKey.c
    ../HARDWARE/button/: button.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIM/: tim.c
    ../SYSTEM/ADC/: adc.c
    ../SYSTEM/gpio/: gpio.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c
  group U8G2
    ../HARDWARE/U8g2_V2.0.0/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group U8G2/user
    ../HARDWARE/U8g2_user/: IIC_OLED.c u8g2_ui.c u8g2_uiCore.c u8g2_uiLayer.c u8g2_uiList.c u8g2_uiPaintingFrame.c u8g2_uiStarrySky.c u8g2_uiText.c u8g2_uiDeviceLink.c
  group DeviceLink
    ../../../library/core/: core.c data.c list.c run.c timer.c
    ../HARDWARE/DeviceLink/: deviceLink.c
